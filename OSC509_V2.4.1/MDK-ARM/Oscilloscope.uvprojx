# Keil uVision project Oscilloscope.uvprojx, settings and files
target STM32H750 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: OSCFUN-FW-V0 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7,__FPU_PRESENT,OSC_STM32H750
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Oscilloscope\osc;..\Oscilloscope\dev;..\Oscilloscope\fos;..\Oscilloscope\dev;..\Oscilloscope\gui;..\Oscilloscope\layer;..\Oscilloscope\hzs;..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\Middlewares\Third_Party\FatFs\src;..\Oscilloscope\dsp;..\Oscilloscope\boot;..\usb_lib;..\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0xf0000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24060000 size 0x80000
  link misc: --keep __FS_*;--keep __FS_TSK_*
  group MDK-ARM
    ../Src/: system_stm32h7xx.c
    ./: startup_stm32h750xx.s
    ./: startup_stm32h7b3xx.s
  group User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group hallib
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_hcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c
  group layer
    ../Oscilloscope/layer/: hal_gpio.c hal_exit.c hal_dac.c hal_iic.c hal_tim.c
    ../Oscilloscope/dev/: bsp_driver_sd.c sdmmc.c sd_diskio.c
  group fos
    ../Oscilloscope/fos/: fos.c fos_tsk.c
  group dev
    ../Oscilloscope/dev/: display_dev.c middle.c led.c k24c02.c touch.c GT9xx.c osc_iwdg.c
    ../usb_lib/: usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c user_diskio.c
  group osc
    ../Oscilloscope/osc/: osc_analog_sample.c osc.c osc_cfg.c osc_api.c osc_line.c osc_ui.c osc_thread.c osc_measure.c osc_menu.c osc_calibrate.c osc_lows.c osc_param.c osc_win.c osc_DAC.c osc_msgbox.c
    ../Src/: usbh_app.c
    ../Oscilloscope/boot/: osc_boot.c
  group gui
    ../Oscilloscope/gui/: gui.c gui_ascii.c gui_dev.c
  group usbh
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group fatfs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Src/: fatfs.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group user_usb
    ../Src/: usb_host.c usbh_conf.c usbh_diskio.c usbh_platform.c user_diskio.c
  group dsp
    ../Oscilloscope/dsp/: arm_cortexM7lfdp_math.lib
  group usbd
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
target STM32H7B0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: OSCFUN-FWB-V0 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7,__FPU_PRESENT,OSC_STM32H7B0
  c include: ../Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\Oscilloscope\osc;..\Oscilloscope\dev;..\Oscilloscope\fos;..\Oscilloscope\dev;..\Oscilloscope\gui;..\Oscilloscope\layer;..\Oscilloscope\hzs;..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\Middlewares\Third_Party\FatFs\src;..\Oscilloscope\dsp;..\Oscilloscope\boot
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  link misc: --keep __FS_*;--keep __FS_TSK_*
software components: CMSIS:CORE 5.3.0
